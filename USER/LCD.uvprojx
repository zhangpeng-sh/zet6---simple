# Keil uVision project LCD.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LCD +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\LCD;..\SYSTEM;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
  group HARDWARE
    ../SRC/HARDWARE/LCD/: lcd.c
  group SYSTEM
    ../SRC/SYSTEM/delay/: delay.c
    ../SRC/SYSTEM/: startup_stm32f10x_md.s
target Debug_RAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LCD +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: VECT_TAB_RAM, STM32F10X_HD
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\LCD;..\SYSTEM;..\SRC\HARDWARE\LCD;..\SRC\SYSTEM;..\SRC\SYSTEM\delay
  memory RVCT4: ROM 0x2000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
  scatter file: .\SRAM_调试 - c8.sct
